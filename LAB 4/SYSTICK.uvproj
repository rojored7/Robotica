# Keil uVision project SYSTICK.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SYSTICK
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
    C:/Keil_v5/ARM/Startup/ST/STM32F4xx/: system_stm32f4xx.c
    ../../MATERIALES/LIBRERIAS DE AYUDA/: tm_stm32f4_gpio.c defines.h tm_stm32f4_gpio.h
  group New Group
    ./: SYSTICK.cpp
    ../../MATERIALES/LIBRERIAS DE AYUDA/: tm_stm32f4_gpio.h tm_stm32f4_gpio.c defines.h
